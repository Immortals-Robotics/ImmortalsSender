# Keil uVision project ImmortalsSender.uvproj, settings and files
target ImmortalsSender (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ImmortalsSender
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,LWIP_IGMP
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\libraries\STM32F2xx_StdPeriph_Driver\inc;..\libraries\STM32F2x7_ETH_Driver\inc;..\libraries\STM32_EVAL;..\libraries\STM32_EVAL\Common;..\libraries\STM32_EVAL\STM322xG_EVAL;..\libraries\lwip_v1.3.2\src\include;..\libraries\lwip_v1.3.2\src\include\lwip;..\libraries\lwip_v1.3.2\src\include\netif;..\libraries\lwip_v1.3.2\src\include\ipv4;..\libraries\lwip_v1.3.2\port\STM32F2x7;..\libraries\lwip_v1.3.2\port\STM32F2x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../src/: system_stm32f2xx.c
  group MDK-ARM
    ../src/: startup_stm32f2xx.s
  group User
    ../src/: main.c netconf.c stm32f2x7_eth_bsp.c stm32f2xx_it.c serial_debug.c udp_echoserver.c
  group LwIP
    ../libraries/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../libraries/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../libraries/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../libraries/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../libraries/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group STM32F2xx_StdPeriph_Driver
    ../libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_usart.c misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_i2c.c stm32f2xx_spi.c stm32f2xx_tim.c
  group STM32F2x7_ETH_Driver
    ../libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM322xG_EVAL
    ../libraries/STM32_EVAL/: stm32_eval.c
    ../libraries/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c
  group NRF24L01
    ../src/: nrf24l01.c nrf24l01_2.c
