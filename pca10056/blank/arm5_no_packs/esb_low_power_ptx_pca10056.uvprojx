# Keil uVision project esb_low_power_ptx_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET ESB_PRESENT FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\components;..\..\..\components\boards;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\components\libraries\atomic;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bsp;..\..\..\components\libraries\delay;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\memobj;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\strerror;..\..\..\components\libraries\util;..\..\..;..\..\..\external\fprintf;..\..\..\external\segger_rtt;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\modules\nrfx;..\..\..\modules\nrfx\drivers\include;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\config;..\..\..\components\libraries\fifo;.\Wiznet;.\Wiznet\ioLibrary_Driver\Ethernet;.\Wiznet\ioLibrary_Driver\Ethernet\W5100;.\Utils;..\..\..\components\proprietary_rf\esb;..\..\..\RTT
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DESB_PRESENT,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\proprietary_rf\esb;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
    ../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Properitary_RF
    ../../../components/proprietary_rf/esb/: nrf_esb.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group Wiznet
    ./Wiznet/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ./Wiznet/ioLibrary_Driver/Ethernet/W5100/: w5100.c
  group Ethernet
    ./Wiznet/: user_ethernet.c user_spi.c
  group Utils
    ./Utils/: mylog.c myNRF.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
